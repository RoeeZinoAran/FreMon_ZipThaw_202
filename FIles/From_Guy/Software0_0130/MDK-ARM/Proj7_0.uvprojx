# Keil uVision project Proj7_0.uvprojx, settings and files
target Proj7_0 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32L073VZTx STMicroelectronics
  pack: Keil.STM32L0xx_DFP.2.0.0
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x802FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0+")
  output: Proj7_0 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32L073xx
  c include: ../Inc;                                                                                             ../Drivers/STM32L0xx_HAL_Driver/Inc;                                                                                             ../Drivers/STM32L0xx_HAL_Driver/Inc/Legacy;                                                                                             ../Drivers/CMSIS/Device/ST/STM32L0xx/Include;                                                                                             ../Drivers/CMSIS/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x30000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ./: startup_stm32l073xx.s
  group Application/User
    ./: ADC.c board_temp.c commserv.c discreets.c error.c heater.c host_from_comm.c host_to_comm.c init.c ir_temp.c miscel.c motor.c pid.c rfid.c technician.c progress.c
    ../Src/: main.c stm32l0xx_it.c stm32l0xx_hal_msp.c
  group Drivers/STM32L0xx_HAL_Driver
    ../Drivers/STM32L0xx_HAL_Driver/Src/: stm32l0xx_hal_adc.c stm32l0xx_hal_adc_ex.c stm32l0xx_hal_i2c.c stm32l0xx_hal_i2c_ex.c stm32l0xx_hal_spi.c stm32l0xx_hal_tim.c stm32l0xx_hal_tim_ex.c stm32l0xx_hal_uart.c stm32l0xx_hal_uart_ex.c stm32l0xx_hal.c stm32l0xx_hal_rcc.c stm32l0xx_hal_rcc_ex.c stm32l0xx_hal_flash_ramfunc.c stm32l0xx_hal_flash.c stm32l0xx_hal_flash_ex.c stm32l0xx_hal_gpio.c stm32l0xx_hal_dma.c stm32l0xx_hal_pwr.c stm32l0xx_hal_pwr_ex.c stm32l0xx_hal_cortex.c
  group Drivers/CMSIS
    ..//Src/: system_stm32l0xx.c
software components: CMSIS:CORE 4.3.0
